# Keil uVision project RGBKeyBoard.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: RGBKeyBoard +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c usb.c DEBUG.C rgbled.c RGBLOAD.ASM
